# Keil uVision project mbed-os-example-blinky.uvprojx, settings and files
target mbed-os-example-blinky (6070000::V6.7::.\ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: CPUTYPE("Cortex-M0")
  output: mbed-os-example-blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=2
  c define: DEVICE_SLEEP=1 BLE_STACK_CONFIGURATION=BLE_STACK_BASIC_CONFIGURATION COMPONENT_NSPE=1 __ASSERT_MSG TARGET_STEVAL_IDB008V2 CMSIS_VECTAB_VIRTUAL_HEADER_FILE=\"cmsis_nvic.h\" TARGET_STMBLUE TARGET_BLUENRG2 TARGET_NAME=STEVAL_IDB008V2 CMSIS_VECTAB_VIRTUAL LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ DEVICE_STDIO_MESSAGES=1 TARGET_RELEASE TARGET_LIKE_MBED DEVICE_SERIAL_FC=1 TARGET_LIKE_CORTEX_M0 ARM_MATH_CM0 TARGET_CORTEX TARGET_CORTEX_M DEVICE_SERIAL=1 MULADDC_CANNOT_USE_R7 MBED_BUILD_TIMESTAMP=1552050744.56 DEVICE_USTICKER=1 BLUENRG2_DEVICE COMPONENT_PSA_SRV_IMPL=1 DEVICE_INTERRUPTIN=1 COMPONENT_PSA_SRV_EMUL=1 TOOLCHAIN_ARM __CORTEX_M0 TOOLCHAIN_ARM_STD DEVICE_SERIAL_ASYNCH=1 __MBED__=1 __MBED_CMSIS_RTOS_CM MBED_TRAP_ERRORS_ENABLED=1 SMPS_INDUCTOR=SMPS_INDUCTOR_10uH TARGET_CORDIO MBED_DEBUG TARGET_M0 __CMSIS_RTOS FEATURE_BLE=1 TOOLCHAIN_ARMC6
  c misc: -fdata-sections -Wno-armcc-pragma-anon-unions -fno-exceptions -g -c --target=arm-arm-none-eabi -fshort-enums -fshort-wchar -mthumb -Wno-armcc-pragma-push-pop -fno-rtti -mcpu=cortex-m0 -include mbed_config.h
  c include: .;mbed-os;mbed-os\cmsis;mbed-os\cmsis\TARGET_CORTEX_M;mbed-os\drivers;mbed-os\events;mbed-os\events\equeue;mbed-os\features\FEATURE_BLE;mbed-os\features\FEATURE_BLE\ble;mbed-os\features\FEATURE_BLE\ble\common;mbed-os\features\FEATURE_BLE\ble\gap;mbed-os\features\FEATURE_BLE\ble\generic;mbed-os\features\FEATURE_BLE\ble\pal;mbed-os\features\FEATURE_BLE\ble\services;mbed-os\features\FEATURE_BLE\source;mbed-os\features\FEATURE_BLE\source\gap;mbed-os\features\FEATURE_BLE\source\generic;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\driver;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\source;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host\include;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host\sources;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host\sources\hci;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host\sources\hci\dual_chip;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host\sources\sec;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host\sources\sec\common;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host\sources\stack;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host\sources\stack\att;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host\sources\stack\cfg;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host\sources\stack\dm;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host\sources\stack\hci;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host\sources\stack\l2c;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\ble-host\sources\stack\smp;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\platform;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\platform\include;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\wsf;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\wsf\include;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\wsf\include\util;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\wsf\sources;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\wsf\sources\port;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack\wsf\sources\port\baremetal;mbed-os\features\FEATURE_BLE\targets\TARGET_CORDIO\stack_adaptation;mbed-os\hal;mbed-os\hal\storage_abstraction;mbed-os\platform;mbed-os\targets\TARGET_STMBLUE;mbed-os\targets\TARGET_STMBLUE\Bluetooth_LE;mbed-os\targets\TARGET_STMBLUE\Bluetooth_LE\inc;mbed-os\targets\TARGET_STMBLUE\DTM;mbed-os\targets\TARGET_STMBLUE\DTM\inc;mbed-os\targets\TARGET_STMBLUE\Periph_Driver;mbed-os\targets\TARGET_STMBLUE\Periph_Driver\inc;mbed-os\targets\TARGET_STMBLUE\TARGET_BLUENRG2\TARGET_STEVAL_IDB008V2;mbed-os\targets\TARGET_STMBLUE\TARGET_BLUENRG2\TARGET_STEVAL_IDB008V2\device;mbed-os\targets\TARGET_STMBLUE\cryptolib;mbed-os\targets\TARGET_STMBLUE\cryptolib\inc;mbed-os\targets\TARGET_STMBLUE\cryptolib\inc\AES;mbed-os\targets\TARGET_STMBLUE\cryptolib\inc\AES\CMAC;mbed-os\targets\TARGET_STMBLUE\cryptolib\inc\AES\Common;mbed-os\targets\TARGET_STMBLUE\cryptolib\inc\Common;mbed-os\targets\TARGET_STMBLUE\hal;mbed-os\targets\TARGET_STMBLUE\hal\inc;D:\Documenti\GitHub\PROVA\mbed-os-example-blinky\mbed-os
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M0,-DBLE_STACK_CONFIGURATION=BLE_STACK_BASIC_CONFIGURATION,-DSMPS_INDUCTOR=SMPS_INDUCTOR_10uH,-DLS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ,-DCMSIS_VECTAB_VIRTUAL,-DARM_MATH_CM0,-D__MBED_CMSIS_RTOS_CM,-DBLUENRG2_DEVICE,-DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h",-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .\.link_script.sct
  link misc: --remove --verbose --legacyalign --show_full_path --predefine="-DMBED_BOOT_STACK_SIZE=4096" --keep=os_cb_sections --cpu=cortex-m0
  group mbed-os
    ./mbed-os/features/FEATURE_BLE/source/gap/: AdvertisingDataBuilder.cpp AdvertisingParameters.cpp ConnectionParameters.cpp
    ./mbed-os/features/FEATURE_BLE/ble/gap/: AdvertisingDataBuilder.h AdvertisingDataParser.h AdvertisingDataSimpleBuilder.h AdvertisingDataTypes.h AdvertisingParameters.h ConnectionParameters.h Events.h Gap.h ScanParameters.h Types.h
    ./mbed-os/targets/TARGET_STMBLUE/cryptolib/inc/AES/: aes.h
    ./mbed-os/targets/TARGET_STMBLUE/cryptolib/inc/AES/CMAC/: aes_cmac.h
    ./mbed-os/targets/TARGET_STMBLUE/cryptolib/inc/AES/Common/: aes_common.h aes_low_level.h
    ./mbed-os/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.cpp MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.cpp QSPI.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SerialWireOutput.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h TableCRC.cpp TableCRC.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    ./mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.cpp LowPowerTickerWrapper.h lp_ticker_api.h mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_lp_ticker_wrapper.cpp mbed_lp_ticker_wrapper.h mbed_pinmap_common.c mbed_pinmap_default.c mbed_ticker_api.c mbed_us_ticker_api.c mpu_api.h pinmap.h port_api.h pwmout_api.h qspi_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h spm_api.h ticker_api.h trng_api.h us_ticker_api.h
    ./mbed-os/cmsis/TARGET_CORTEX_M/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mbed_fault_handler.c mbed_fault_handler.h mbed_tz_context.c mpu_armv7.h mpu_armv8.h tz_context.h
    ./mbed-os/features/FEATURE_BLE/ble/: ArrayView.h BLE.h blecommon.h BLEInstanceBase.h BLEProtocol.h BLERoles.h BLETypes.h CallChainOfFunctionPointersWithContext.h CharacteristicDescriptorDiscovery.h deprecate.h DiscoveredCharacteristic.h DiscoveredCharacteristicDescriptor.h DiscoveredService.h FunctionPointerWithContext.h Gap.h GapAdvertisingData.h GapAdvertisingParams.h GapEvents.h GapScanningParams.h GattAttribute.h GattCallbackParamTypes.h GattCharacteristic.h GattClient.h GattServer.h GattServerEvents.h GattService.h SafeBool.h SafeEnum.h SecurityManager.h ServiceDiscovery.h UUID.h
    ./mbed-os/targets/TARGET_STMBLUE/hal/inc/: asm.h bluenrg_x_device.h clock.h compiler.h crash_handler.h fifo.h gp_timer.h hal_radio.h hal_types.h miscutil.h osal.h system_bluenrg.h
    ./mbed-os/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h CThunkBase.cpp CThunkBase.h DeepSleepLock.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_crash_data_offsets.h mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_error_hist.c mbed_error_hist.h mbed_interface.c mbed_interface.h mbed_mem_trace.cpp mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_mpu_mgmt.c mbed_mpu_mgmt.h mbed_poll.cpp mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_sleep_manager.c mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h semihost_api.h SharedPtr.h SingletonPtr.h sleep.h Span.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/ble-host/include/: att_api.h att_defs.h att_handler.h att_uuid.h dm_api.h dm_handler.h hci_api.h hci_cmd.h hci_core.h hci_drv.h hci_evt.h hci_handler.h hci_tr.h l2c_api.h l2c_defs.h l2c_handler.h sec_api.h smp_api.h smp_defs.h smp_handler.h svc_core.h
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/ble-host/sources/stack/att/: att_main.c att_main.h att_sign.h att_uuid.c attc_disc.c attc_main.c attc_main.h attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_csf.c atts_dyn.c atts_ind.c atts_main.c atts_main.h atts_proc.c atts_read.c atts_sign.c atts_write.c
    ./mbed-os/features/FEATURE_BLE/ble/pal/: AttClient.h AttClientToGattClientAdapter.h AttServerMessage.h ConnectionEventMonitor.h Deprecated.h EventQueue.h GapEvents.h GapTypes.h GenericAccessService.h PalGap.h PalGattClient.h PalSecurityManager.h SigningEventMonitor.h SimpleAttServerMessage.h
    ./mbed-os/features/FEATURE_BLE/ble/services/: BatteryService.h DeviceInformationService.h DFUService.h EddystoneConfigService.h EddystoneService.h EnvironmentalService.h HealthThermometerService.h HeartRateService.h iBeacon.h LinkLossService.h UARTService.h URIBeaconConfigService.h
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/wsf/sources/util/: bda.c bstream.c calc128.c crc32.c fcs.c prand.c print.c terminal.c wstr.c
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/wsf/include/util/: bda.h bstream.h calc128.h crc32.h fcs.h prand.h print.h terminal.h wstr.h
    ./mbed-os/features/FEATURE_BLE/source/: BLE.cpp BLEInstanceBase.cpp DiscoveredCharacteristic.cpp GapScanningParams.cpp
    ./mbed-os/targets/TARGET_STMBLUE/Bluetooth_LE/inc/: ble_status.h bluenrg1_api.h bluenrg1_events.h bluenrg1_stack.h stack_user_cfg.h
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/: BleImplementationForward.h CordioBLE.h CordioGattServer.h CordioPalAttClient.h CordioPalGap.h CordioPalGenericAccessService.h CordioPalSecurityManager.h SigningMonitorProxy.h SimpleEventQueue.h
    ./mbed-os/targets/TARGET_STMBLUE/Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_radio.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
    ./mbed-os/targets/TARGET_STMBLUE/Periph_Driver/inc/: BlueNRG1_adc.h BlueNRG1_dma.h BlueNRG1_flash.h BlueNRG1_gpio.h BlueNRG1_i2c.h BlueNRG1_mft.h BlueNRG1_pka.h BlueNRG1_radio.h BlueNRG1_rng.h BlueNRG1_rtc.h BlueNRG1_spi.h BlueNRG1_sysCtrl.h BlueNRG1_uart.h BlueNRG1_wdg.h misc.h
    ./mbed-os/targets/TARGET_STMBLUE/DTM/inc/: BlueNRG1_conf.h DTM_boot.h DTM_cmd_db.h DTM_config.h
    ./mbed-os/targets/TARGET_STMBLUE/TARGET_BLUENRG2/TARGET_STEVAL_IDB008V2/device/: BlueNRG2.h cmsis.h cmsis_nvic.c cmsis_nvic.h system_bluenrg2.h
    ./mbed-os/targets/TARGET_STMBLUE/DTM/: BlueNrgHCIDriver.cpp
    ./mbed-os/features/FEATURE_BLE/ble/common/: Bounded.h Duration.h StaticInterface.h
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/ble-host/sources/stack/cfg/: cfg_stack.c cfg_stack.h
    ./mbed-os/targets/TARGET_STMBLUE/hal/src/: clock.c context_switch.S fifo.c gp_timer.c hal_radio.c miscutil.c osal.c system_bluenrg1.c
    ./mbed-os/targets/TARGET_STMBLUE/cryptolib/inc/: config.h crypto.h
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/source/: CordioBLE.cpp CordioGattServer.cpp CordioImplementations.cpp CordioPalAttClient.cpp
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/driver/: CordioHCIDriver.cpp CordioHCIDriver.h CordioHCITransportDriver.cpp CordioHCITransportDriver.h H4TransportDriver.cpp H4TransportDriver.h
    ./mbed-os/targets/TARGET_STMBLUE/TARGET_BLUENRG2/TARGET_STEVAL_IDB008V2/: device.h objects.h PeripheralNames.h PinNames.h
    ./mbed-os/features/FEATURE_BLE/source/services/: DFUService.cpp UARTService.cpp URIBeaconConfigService.cpp
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/ble-host/sources/stack/dm/: dm_adv.c dm_adv.h dm_adv_ae.c dm_adv_leg.c dm_conn.c dm_conn.h dm_conn_cte.c dm_conn_master.c dm_conn_master_ae.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_ae.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev.h dm_dev_priv.c dm_main.c dm_main.h dm_past.c dm_phy.c dm_phy.h dm_priv.c dm_priv.h dm_scan.c dm_scan.h dm_scan_ae.c dm_scan_leg.c dm_sec.c dm_sec.h dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c dm_sync_ae.c
    ./mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    ./mbed-os/targets/TARGET_STMBLUE/DTM/src/: DTM_boot.c DTM_cmd_db.c
    ./mbed-os/events/equeue/: equeue.c equeue.h equeue_mbed.cpp equeue_platform.h equeue_posix.c
    ./mbed-os/targets/TARGET_STMBLUE/cryptolib/inc/Common/: err_codes.h macros.h sk.h types.h
    ./mbed-os/events/: Event.h EventQueue.cpp EventQueue.h mbed_events.h mbed_shared_queues.cpp mbed_shared_queues.h
    ./mbed-os/cmsis/TARGET_CORTEX_M/TOOLCHAIN_ARM/: except.S
    ./mbed-os/features/FEATURE_BLE/source/generic/: FileSecurityDb.cpp
    ./mbed-os/features/FEATURE_BLE/ble/generic/: FileSecurityDb.h GenericGap.h GenericGattClient.h GenericSecurityManager.h MemorySecurityDb.h SecurityDb.h
    ./mbed-os/targets/TARGET_STMBLUE/: gpio_api.c gpio_irq_api.c mbed_overrides.c mbed_rtx.h pinmap.c serial_api.c sleep_api.c spi_api.c us_ticker_api.c
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/ble-host/sources/hci/dual_chip/: hci_cmd.c hci_cmd_ae.c hci_cmd_cte.c hci_cmd_past.c hci_cmd_phy.c hci_core_ps.c hci_core_ps.h hci_evt.c hci_vs_ae.c
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/ble-host/sources/hci/common/: hci_core.c
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/wsf/include/: hci_defs.h wsf_assert.h wsf_buf.h wsf_bufio.h wsf_cs.h wsf_detoken.h wsf_efs.h wsf_heap.h wsf_math.h wsf_msg.h wsf_nvm.h wsf_os.h wsf_queue.h wsf_timer.h wsf_trace.h wsf_types.h
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack_adaptation/: hci_drv.c hci_mbed_os_adaptation.h hci_tr.c hci_vs.c pal_mbed_os_adaptation.cpp wsf_cs.c wsf_mbed_os_adaptation.c wsf_mbed_os_adaptation.h wsf_os.c
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/ble-host/sources/stack/hci/: hci_main.c hci_main.h
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_main.h l2c_master.c l2c_slave.c
    ./mbed-os/: mbed.h
    ./mbed-os/cmsis/: mbed_cmsis_conf.h RTE_Components.h
    ./mbed-os/hal/mpu/: mbed_mpu_v7m.c mbed_mpu_v8m.c
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/platform/include/: pal_audio_amp.h pal_bb.h pal_bb_ble.h pal_bb_ble_tester.h pal_btn.h pal_cfg.h pal_crypto.h pal_io_exp.h pal_led.h pal_nvm.h pal_radio.h pal_rtc.h pal_sys.h pal_timer.h pal_twi.h pal_types.h pal_uart.h
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/ble-host/sources/sec/common/: sec_aes.c sec_ccm_hci.c sec_cmac_hci.c sec_ecc_hci.c sec_main.c sec_main.h
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/ble-host/sources/sec/pal/: sec_ccm.c
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/ble-host/sources/stack/smp/: smp_act.c smp_db.c smp_main.c smp_main.h smp_non.c smp_sc_act.c smp_sc_main.c smp_sc_main.h smpi_act.c smpi_main.h smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_main.h smpr_sc_act.c smpr_sc_sm.c smpr_sm.c
    ./mbed-os/targets/TARGET_STMBLUE/Bluetooth_LE/src/: stack_dle_api_stubs.c stack_priv_api_stubs.c stack_sc_api_stubs.c stack_slvonly_api_stubs.c stack_user_cfg.c
    ./mbed-os/features/FEATURE_BLE/targets/TARGET_CORDIO/stack/wsf/sources/port/baremetal/: wsf_assert.c wsf_buf.c wsf_bufio.c wsf_detoken.c wsf_efs.c wsf_heap.c wsf_msg.c wsf_nvm.c wsf_os_int.h wsf_queue.c wsf_timer.c wsf_trace.c
  group mbed-os-example-blinky
    ./: main.cpp stats_report.h
    ./: mbed_config.h
